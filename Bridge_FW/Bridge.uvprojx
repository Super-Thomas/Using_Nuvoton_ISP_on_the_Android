# Keil uVision project Bridge.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Bridge
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\Nano100Series\Include;.\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c hid_transfer.h hid_transfer.c descriptors.c
  group Library
    ./Library/StdDriver/src/: clk.c usbd.c sys.c retarget.c uart.c timer.c
  group CMSIS
    ./Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ./Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
